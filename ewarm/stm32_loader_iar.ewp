# IAR project stm32_loader_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; _DLIB_FILE_DESCRIPTOR; HSE_VALUE=8000000; STM32F40_41xxx; ARM_MATH_CM4; USE_USB_OTG_FS
  ICCARM.CCIncludePath2: ..; ..\periph; ..\utils; ..\Library\CMSIS\Include; ..\Library\CMSIS\Device\ST\STM32F4xx\Include; ..\Library\STM32F4xx_StdPeriph_Driver\inc; ..\Library\STM32F407-Discovery; ..\Library\fatfs
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: stm32_loader_iar.sim
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ../: main.c
  group Library/CMSIS
    ../Library/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40_41xxx.s
    ../periph/: system_stm32f4xx.c
  group Library/fatfs
    ../Library/fatfs/: ff.c
  group Library/STM32F407-Discovery
    ../Library/STM32F407-Discovery/: stm32_sdio_sd.c stm32_spi_sd.c stm32f4_discovery.c
  group Library/STM32F4xx_StdPeriph_Driver
    ../Library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group periph
    ../periph/: led.c stm32f4xx_it.c systick.c
  group utils
    ../utils/: utils.c
